# Copyright (c) 2018 LG Electronics, Inc.

# PV is the version of the enact-dev distribution, as tagged in the
# enyojs/enact-dev-dist repository on GitHub. This version should correspond to the
# tag whose hash is specified in SRCREV, so PV and SRCREV will always change
# together.

PV = "1.0.7"
SRCREV = "6289e835603bf407f7e75e9fabc8649529f85131"

EXTENDPRAUTO_append = "r2d21"
