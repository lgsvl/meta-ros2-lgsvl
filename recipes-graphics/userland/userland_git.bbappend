FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0002-add-mmal-raspicam-support.patch"
