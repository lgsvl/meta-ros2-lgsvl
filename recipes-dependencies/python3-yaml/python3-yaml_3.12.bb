require python-pyyaml.inc
inherit setuptools3
