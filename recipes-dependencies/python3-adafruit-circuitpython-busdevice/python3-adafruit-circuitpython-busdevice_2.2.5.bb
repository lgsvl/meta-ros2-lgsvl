SUMMARY = "adafruit-circuitpython-busdevice package 2.2.5 for python 3"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6ec69d6e9e6c85adfb7799d7f8cf044e"

PYPI_PACKAGE = "adafruit-circuitpython-busdevice"

inherit pypi setuptools3

SRC_URI[sha256sum] = "b7c29f20c1f24a6c302cecc2cee16c247e8be647a01e1934c92e2b507a14360f"
