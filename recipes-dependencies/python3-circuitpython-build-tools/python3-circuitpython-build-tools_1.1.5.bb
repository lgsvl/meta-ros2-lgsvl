SUMMARY = "circuitpython-build-tools 1.1.5 package for python 3"
LICENSE = "MIT"
LIC_FILES_CHKSUM="file://LICENSE;md5=asfasfa"

PYPI_PACKAGE = "circuitpython-build-tools"

inherit pypi setuptools3

SRC_URI[sha256sum] = "cce6a964620073999f68934db6bd98f9c4767755a04c818557c9b8d699a83107"
